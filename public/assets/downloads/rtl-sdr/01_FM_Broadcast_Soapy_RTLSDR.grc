options:
  parameters:
    author: Prajwal Bhattaram
    description: Soapy RTL-SDR normal tuner. 105.3 MHz example; change centre frequency for other areas. FFT filter 2400000 -> 240000, WBFM 240000 -> 48000.
    generate_options: qt_gui
    id: chipsncode_fm_receiver
    output_language: python
    title: ChipsnCode - FM broadcast receiver
  states: {}

blocks:
- name: rf_rate
  id: variable
  parameters:
    comment: Receiver sample rate, samples per second
    value: '2400000'
  states: {}
- name: station_freq
  id: variable
  parameters:
    value: '105300000'
    comment: 'Example: 105.3 MHz. Replace with a strong local FM station in hertz.'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    type: fc32
    dev_args: ''''''
    samp_rate: rf_rate
    center_freq: station_freq
    bufflen: '262144'
    comment: Normal tuner mode. Change station_freq to a strong local FM broadcast.
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    type: ccc
    decim: '10'
    gain: '1'
    samp_rate: rf_rate
    cutoff_freq: '100000'
    width: '10000'
    win: window.WIN_HAMMING
    comment: Retain the desired FM signal; reduce 2400000 samples/s to 240000.
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    quad_rate: '240000'
    audio_decimation: '5'
    comment: Recover mono FM audio at 48000 samples per second.
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Mono FM audio, 48000 samples per second, float samples
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: rf_rate
    fc: station_freq
    fftsize: '4096'
    grid: 'True'
    label: Relative gain
    label1: Raw FM spectrum
    name: FM spectrum
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymax: '0'
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
