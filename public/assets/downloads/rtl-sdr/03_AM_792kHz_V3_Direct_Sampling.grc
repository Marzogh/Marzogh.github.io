options:
  parameters:
    author: Prajwal Bhattaram
    description: Medium-wave AM example at 792 kHz; substitute a local service if needed. RTL-SDR Blog V3 Q-branch direct_samp=2 configured in Soapy Custom Source Ch0 Other settings. Live reception requires suitable antenna and coverage.
    generate_options: qt_gui
    id: chipsncode_am_792_q_branch
    output_language: python
    title: ChipsnCode - 792 kHz AM V3 Q-branch
  states: {}

blocks:
- name: rf_rate
  id: variable
  parameters:
    comment: Soapy RTL-SDR sample rate (Hz)
    value: '2400000'
  states: {}
- name: station_freq
  id: variable
  parameters:
    value: '792000'
    comment: Example medium-wave AM frequency. Change to a local AM station if needed.
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    driver: '''rtlsdr'''
    type: fc32
    dev_args: ''''''
    stream_args: ''''''
    samp_rate: rf_rate
    tune_args0: ''''''
    settings0: '''direct_samp=2'''
    antenna0: '''RX'''
    center_freq0: station_freq + 50000
    gain0: '0'
    dc_removal0: 'False'
    comment: 'RTL-SDR Blog V3 direct sampling: Q branch. The channel-specific Other settings value is direct_samp=2. This is not a normal tuner configuration.'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccf
    decim: '30'
    taps: firdes.low_pass(1, rf_rate, 5000, 2000, window.WIN_HAMMING)
    center_freq: '-50000'
    samp_rate: rf_rate
    comment: Select AM channel; 2400000/30 = 80000 samples/s.
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: AM envelope detection; selected complex channel at 80000 samples per second.
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    type: ff
    length: '256'
    long_form: 'True'
    comment: Remove varying carrier/DC level from real demodulated AM audio.
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    type: fff
    interp: '3'
    decim: '5'
    comment: 80000 * 3/5 = 48000 samples/s.
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Live mono AM audio, 48 kHz, float samples
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: rf_rate
    fc: station_freq + 50000
    fftsize: '4096'
    grid: 'True'
    label: Relative gain
    label1: Direct-sampled RF
    name: Received RF spectrum (tuned 50 kHz high)
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymax: '0'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: rf_rate / 30
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label: Relative gain
    label1: Filtered AM channel
    name: 'Selected AM station: translated baseband'
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymax: '0'
  states: {}

connections:
- [soapy_custom_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
