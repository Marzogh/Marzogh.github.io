options:
  parameters:
    author: Prajwal Bhattaram
    description: Aircraft AM example at 125.6 MHz, Brisbane Approach south-east sector. Soapy RTLSDR, tuning 50000 Hz above target and frequency translating filter. 2400000 -> 80000 -> 48000.
    generate_options: qt_gui
    id: chipsncode_am_normal
    output_language: python
    title: ChipsnCode - AM using normal tuner
  states: {}

blocks:
- name: rf_rate
  id: variable
  parameters:
    comment: Soapy RTL-SDR sample rate (Hz)
    value: '2400000'
  states: {}
- name: station_freq
  id: variable
  parameters:
    value: '125600000'
    comment: 'Brisbane Approach south-east sector: 125.6 MHz. Change to a local AM signal.'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    type: fc32
    dev_args: ''''''
    samp_rate: rf_rate
    center_freq: station_freq + 50000
    bufflen: '262144'
    comment: Normal tuner mode; 50000 Hz above the wanted AM signal.
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccf
    decim: '30'
    taps: firdes.low_pass(1, rf_rate, 5000, 2000, window.WIN_HAMMING)
    center_freq: '-50000'
    samp_rate: rf_rate
    comment: Select AM channel; 2400000/30 = 80000 samples/s.
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: AM envelope detection; selected complex channel at 80000 samples per second.
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    type: ff
    length: '256'
    long_form: 'True'
    comment: Remove varying carrier/DC level from real demodulated AM audio.
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    type: fff
    interp: '3'
    decim: '5'
    comment: 80000 * 3/5 = 48000 samples/s.
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Live mono AM audio, 48 kHz, float samples
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: rf_rate
    fc: station_freq + 50000
    fftsize: '4096'
    grid: 'True'
    label: Relative gain
    label1: Normal-tuner RF
    name: Received RF spectrum (tuned 50 kHz high)
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymax: '0'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: rf_rate / 30
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    label: Relative gain
    label1: Filtered AM channel
    name: 'Selected AM station: translated baseband'
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymax: '0'
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
